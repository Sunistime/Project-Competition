# Keil uVision project dayurobot_BIG_balance_car.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: standard_balance +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\EXTI;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\ENCODER;..\DAYU\CONTROL;..\HARDWARE\PWM;..\HARDWARE\MOTOR;..\HARDWARE\TIMER;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Include;..\OBJ;..\CORE;..\HARDWARE\Track;..\HARDWARE\TCS3200;..\HARDWARE\OLED;..\DAYU\SHOW;..\HARDWARE\USART2;..\HARDWARE\DuJi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group DAYU
    ../DAYU/CONTROL/: control.c
    ../DAYU/SHOW/: SHOW.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/Track/: Track.c
    ../HARDWARE/TCS3200/: TCS3200.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/DuJi/: DuJi.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
